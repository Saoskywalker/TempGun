# Keil uVision project hammer.uvproj, settings and files
target GPIO (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: hammer +hex
  c flags: Optimize=4 SizeSpeed=1
  c define: FOSC_160000
  c include: .\User Inc;.\N76E003\Include;.\Library\delay;.\Library\OLED IIC;.\Library\MLX90615
  group User Src
    ./User Src/: UserBaseLib.c main.c interrupt.c
  group N76E003 Src
    ./N76E003/Startup/: STARTUP.A51
    ./N76E003/Source/: N76E003_BSP.c
  group Library
    ./Library/delay/: delay.c
    ./Library/OLED IIC/: oled.c
    ./Library/MLX90615/: mlx90615.c myiic.c
